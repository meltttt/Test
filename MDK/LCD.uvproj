# Keil uVision project LCD.uvproj, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: test
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Source\Lcd
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup code
    ../LPC17xx/: startup_LPC17xx.s system_LPC17xx.c
  group User
    ../Source/User/: main.c
  group Lcd
    ../Source/Lcd/: Lcd.c
  group Picture
    ../Source/Picture/: Bg_16bpp_b.c Bg_16bpp_l.c Bg_16bpp_r.c Bg_16bpp_t.c ARM_Ani_16bpp.c
  group Documentation
    ../: Abstract.txt
